# Keil uVision project uart_nuevo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uart_nuevo
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ;..\..\..\nuevos_ejemplos\W7500x_StdPeriph_Lib-master (1)\W7500x_StdPeriph_Lib-master\Libraries\CMSIS\Include;..\..\..\nuevos_ejemplos\W7500x_StdPeriph_Lib-master (1)\W7500x_StdPeriph_Lib-master\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\nuevos_ejemplos\W7500x_StdPeriph_Lib-master (1)\W7500x_StdPeriph_Lib-master\Libraries\W7500x_StdPeriph_Driver\inc;..\..\..\nuevos_ejemplos\W7500x_StdPeriph_Lib-master (1)\W7500x_StdPeriph_Lib-master\Libraries\CMSIS\Include;..\UART_Interrupt
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../nuevos_ejemplos/W7500x_StdPeriph_Lib-master (1)/W7500x_StdPeriph_Lib-master/Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_w7500x.s
  group CMSIS
    ../../../nuevos_ejemplos/W7500x_StdPeriph_Lib-master (1)/W7500x_StdPeriph_Lib-master/Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_w7500x.c
  group W7500_Periphs
    ../../../nuevos_ejemplos/W7500x_StdPeriph_Lib-master (1)/W7500x_StdPeriph_Lib-master/Libraries/W7500x_StdPeriph_Driver/src/: w7500x_crg.c w7500x_uart.c w7500x_gpio.c w7500x_misc.c
  group User
    ./: main.c retarget.c w7500x_it.c
