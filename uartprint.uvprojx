# Keil uVision project uartprint.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uartprint
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: .\workspace\Libraries\CMSIS\Device\WIZnet\W7500\Include;.\workspace\Libraries\W7500x_stdPeriph_Driver\inc;.\workspace\Libraries\CMSIS\Include;..\rs232w7500
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ./workspace/Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ./workspace/Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_PERIFERICOS
    ./workspace/Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_uart.c
  group USER
    ./: main.c retarget.c W7500x_it.c W7500x_it.h eeprom.c eeprom.h main.h lintech.c lintech.h
